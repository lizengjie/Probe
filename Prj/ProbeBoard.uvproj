# Keil uVision project ProbeBoard.uvproj, settings and files
target flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ProbeBoard +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\FWLIB\include;..\cmsis;..\App;..\Bsp
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./: startup_LPC17xx.s
  group fwlib
    ../FWLIB/source/: lpc17xx_timer.c lpc17xx_uart.c lpc17xx_gpio.c lpc17xx_iap.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_clkpwr.c lpc17xx_pwm.c
  group cmsis
    ../cmsis/: system_LPC17xx.c
  group app
    ../App/: main.c dispose.c motor.c
  group bsp
    ../Bsp/: gpio.c pwm.c uart.c timer.c
